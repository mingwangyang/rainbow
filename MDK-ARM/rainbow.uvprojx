# Keil uVision project rainbow.uvprojx, settings and files
target rainbow (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rainbow +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F10X_HD,STM32F103xE,USE_HAL_DRIVER,STM32F103xE,LOS_KERNEL_DEBUG_OUT
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Lite OS\arch\inc;..\Lite OS\kernel\inc;..\Lite OS\kernel\inc_ph;..\Lite OS\OS_CONFIG;..\USER\inc;..\SYSTEM\sys;..\SYSTEM\json
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c tim.c usart.c usb.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Lite OS/arch
    ../Lite OS/arch/src/: los_dispatch_keil.S los_hw.c los_hw_tick.c los_hwi.c
  group Lite OS/kernel
    ../Lite OS/kernel/src/: los_err.c los_event.c los_heap.c los_init.c los_membox.c los_memcheck.c los_memory.c los_memstat.c los_misc.c los_mux.c los_priqueue.c los_queue.c los_sem.c los_slab.c los_slabmem.c los_swtmr.c los_sys.c los_task.c los_tick.c los_tickless.c los_timeslice.c
software components: CMSIS:CORE 5.2.0
